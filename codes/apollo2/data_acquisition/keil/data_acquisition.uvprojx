# Keil uVision project data_acquisition.uvprojx, settings and files
target data_acquisition (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: AMAPH1KK-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.0.0
  cpu: IROM(0x00000000,0x100000) IRAM(0x10000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(24000000) ELITTLE
  output: data_acquisition
  AfterMake: fromelf --bin --output bin\data_acquisition.bin bin\data_acquisition.axf
  AfterMake: fromelf -cedrst --output bin\data_acquisition.txt bin\data_acquisition.axf
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AM_PACKAGE_BGA AM_PART_APOLLO2 keil ARM_MATH_CM4
  c include: ../src;C:\AmbiqMicro\AmbiqSuite\boards\apollo2_evb\bsp;C:\AmbiqMicro\AmbiqSuite\utils;C:\AmbiqMicro\AmbiqSuite\devices;C:\AmbiqMicro\AmbiqSuite\mcu\apollo2;C:\AmbiqMicro\AmbiqSuite;./include
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x40000
  scatter file: .\data_acquisition.sct
  link misc: C:\AmbiqMicro\AmbiqSuite\mcu/apollo2/hal/keil/bin/libam_hal.lib(am_hal_global.o) --keep=am_hal_global.o(.data)
  group src
    ../src/: main.c
  group utils
    C:/AmbiqMicro/AmbiqSuite/utils/: am_util_delay.c am_util_faultisr.c am_util_stdio.c
  group keil
    ../keil/: startup_keil.s
  group lib
    C:/AmbiqMicro/AmbiqSuite/boards/apollo2_evb/bsp/keil/bin/: libam_bsp.lib
    C:/AmbiqMicro/AmbiqSuite/mcu/apollo2/hal/keil/bin/: libam_hal.lib
  group include
    ./include/: apollo2_device.h helper.c helper.h trained_model.h data.h feature_extraction.h feature_extraction.c adc_sampling.h
    C:/Keil_v5/ARM/ARMCLANG/include/: time.h
    ./: adc_sampling.c
  group devices
    C:/AmbiqMicro/AmbiqSuite/devices/: am_devices_led.c
software components: CMSIS:CORE 5.0.1, CMSIS:DSP 1.5.1
